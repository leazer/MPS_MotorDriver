# Keil uVision project MPS_MotorDriver.uvprojx, settings and files
target MPS_MotorDriver (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: AT32M412KBU7-4 ArteryTek
  pack: ArteryTek.AT32M412_416_DFP.2.0.4
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x1F400) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MPS_MotorDriver +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: AT32M412KBU7_4, USE_STDPERIPH_DRIVER, DEBUG
  c include: ..\..\libraries\drivers\inc;..\..\libraries\cmsis\cm4\core_support;..\..\libraries\cmsis\cm4\device_support;..\inc;..\..\middlewares\msp\ma600;..\..\middlewares\rt-thread\include;..\..\middlewares\rt-thread\components\finsh;..\..\application;..\..\application\motor_control;..\..\platform\at32m412;..\..\communication
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group user
    ../src/: at32m412_416_int.c at32m412_416_wk_config.c main.c rtthread_app.c board.c
  group application/motor_control
    ../../application/motor_control/: motor_control.c foc_core.c current_loop.c current_reconstruction.c speed_loop.c position_loop.c joint_config.c motor_control_isr.c fault_manager.c motor_calibration.c encoder_service.c encoder_tracker.c
  group application
    ../../application/: motor_app.c motor_shell.c
  group platform/at32m412
    ../../platform/at32m412/: board_init_at32m412.c board_usart1_dma.c motor_pwm_at32m412.c current_sense_at32m412.c motor_encoder_at32m412.c encoder_acq_timer_at32m412.c motor_protect_at32m412.c flash_calibration_at32m412.c flash_joint_config_at32m412.c clock_at32m412.c
  group communication
    ../../communication/: can_protocol.c can_at32m412.c
  group firmware
    ../../libraries/drivers/src/: at32m412_416_crm.c at32m412_416_tmr.c at32m412_416_ertc.c at32m412_416_gpio.c at32m412_416_i2c.c at32m412_416_usart.c at32m412_416_pwc.c at32m412_416_adc.c at32m412_416_spi.c at32m412_416_dma.c at32m412_416_debug.c at32m412_416_flash.c at32m412_416_crc.c at32m412_416_wwdt.c at32m412_416_wdt.c at32m412_416_exint.c at32m412_416_misc.c at32m412_416_scfg.c at32m412_416_can.c at32m412_416_dac.c at32m412_416_cmp.c at32m412_416_op.c
  group cmsis
    ./: startup_at32m412_416.s
    ../../libraries/cmsis/cm4/device_support/: system_at32m412_416.c
  group middlewares/msp/ma600
    ../../middlewares/msp/ma600/: ma600a.c ma600a_at32_spi2.c
  group middlewares/rt-thread/kernel
    ../../middlewares/rt-thread/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c
  group middlewares/rt-thread/libcpu
    ../../middlewares/rt-thread/libcpu/arm/cortex-m4/: cpuport.c context_rvds.s
  group middlewares/rt-thread/components/finsh
    ../../middlewares/rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c
